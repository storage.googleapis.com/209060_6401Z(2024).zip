Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-11-26T14:43:51+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternate UI 23.0.11.19

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level

# IfcFlowTerminal: 6401Z(2024):6401Z Washbasin faucet, 24/48 V, Bluetooth, 6401Z(2024):6401Z Washbasin faucet, 24/48 V, Bluetooth:492795
In: Level 1
Type - Material: Chrome
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - InletConnectionSize: 16 mm; NominalDepth: 135.869 mm; NominalHeight: 217.867 mm; NominalWidth: 124.247 mm
Type - Electrical - Bluetooth: 5.x (D060577); Electrical Connection: 24-48V; Operating Voltage: 24 V; Protection Class: IP 67
Type - General - Author: BIMStone; BIMObjectName: 6401Z(2024); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: 1; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 2; VersionDate: 2025/10/01
Type - Green Building Properties - Approval KIWA SE Type Approval: 1861; CO2 Emissions (A1-A3): 10.49; CO2 Emissions (A4): 0.42; CO2 Emissions (B7): 430; CO2 Emissions (C2): 0.02; CO2 Emissions (C3): 0.02; CO2 Emissions (C4): 0.28; CO2 Emissions (D): -7.59; EMC Directive: Radio Equipment Directive 2014/53/EU , Low Voltage Directive 2014/35/EU , EMC Directive 2014/30/EU , RoHS Directive 2011/65/EU; EN Standard: EN 15091,ETSI EN 301 489-1 V1.9.2 , ETSI EN 300 328 v2.2.2 , EN 61000-6-1:2007 , EN 61000-6-3:2007+A1:2011+AC:2012 , EN 60335-1:2012+A11+A13+A1+A14+A2+A15:2021, Part 19.11.4; ETIM Class Number: EC011328 Washbasin mixing tap; Noise Class: I (ISO 3822); NRF Number: 4203726; STF Certificate: K14606-01; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/6401Z; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL Environmental Product Declaration EPD: http://static.oras.com/EPD/6401Z; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL KIWA SE Type Approval: http://static.oras.com/KIWASETypeApproval/6401Z; URL Materials Declaration: http://www.oras.com/fileadmin/resources/199831_6401Z_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL STF: http://static.oras.com/STF/6401Z; URL UWL: http://static.oras.com/UWL/6401Z; URL WEEE: http://static.oras.com/WEEE/6401Z
Type - Identity Data - 3D View: https://static.oras.com/3D/6401Z; Catalog Drawing URL: http://static.oras.com/catdrw/6401Z; Category B2B: Public & Semi-public; Dimension Drawing URL: http://static.oras.com/dimdrw/6401Z; FDV Document URL: http://www.oras.com/datasheet/6401Z/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/6401Z; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/6401Z; Interactive AR View URL: https://static.oras.com/AR/6401Z; Long Marketing: Touchless Bluetooth washbasin faucet with a mixing valve. Electrical connection 24/48 V. Recognition range can be adjusted at the faucet. The faucet is equipped with litter filters and non-return valves.(Oras No. 197033/m) 3 - 6 and 9 meters photocell cables availableAdjust settings from Bluetooth appAuto Flush RecognitionAfter flowMax Flow time; Manufacturer: Oras; Mobile Product Information URL: http://mpi.oras.com/6401Z; Model: 6401Z Washbasin faucet, 24/48 V, Bluetooth; Name_en: 6401Z Washbasin faucet, 24/48 V, Bluetooth; OmniClass Number: 23.45.55.00; Product Code: 6401Z; Product Family: Oras Electra; Product Image URL: http://static.oras.com/image/6401Z; Product URL: http://static.oras.com/6401Z; Replacement to: 6401; Spare-Part Information URL: http://static.oras.com/sp/6401Z; Technical DataSheet URL: http://www.oras.com/datasheet/6401Z/en; Type Name: 6401Z Washbasin faucet, 24/48 V, Bluetooth; Usage Group: Trains; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Aerator: Standard aerator; Afterflow Period: 3 s (1-20 s); Automatic Flush Frequency: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Backflow Prevention EN1717: EB; Electronic Parts: Infrared sensor; Flow Rate At 300kPa With Flow Controller: 0.1 m3/s; Installation Type: Deck mounted; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 C; Max Flow Period: 2 min (1 - 1800 s); Mechanical Parts: Non-return valve(s);Litter filter(s); Mounting Holes: 1 hole; Operating Distance: 0-130 mm (0-400 mm); Surface treatment: Chrome; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6401Z(2024); Features: Touchless;External transformer;Bluetooth®; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6401Z; Name: 6401Z Washbasin faucet, 24/48 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 125x135x220 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 6401Z; Manufacturer: Oras
Type - Pset_ProductRequirements - Name: 6401Z Washbasin faucet, 24/48 V, Bluetooth; Category: Plumbing Fixtures
Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 6401Z Washbasin faucet, 24/48 V, Bluetooth; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0735522 m2; Volume: 0.00367789 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 6401Z(2024); Family and Type: 6401Z(2024): 6401Z Washbasin faucet, 24/48 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6401Z Washbasin faucet, 24/48 V, Bluetooth; Type Id: 492779; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
